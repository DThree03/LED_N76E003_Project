# Keil uVision project Project.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Library\DeviceDriver;..\Library\StdDriver\inc
  group Source Code
    ./Code/: main.c initsystem.c Serial_Link_Task.c
  group Library
    ../Library/StdDriver/src/: TM1629A_MRLG.c Queue.c Uart_Buff.c
  group Startup
    ../Library/Startup/Keil/: STARTUP.A51
